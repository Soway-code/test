# IAR project RTT-nano.ewp, settings and files
configuration RTT-nano (ARM, debug)
  General.OGChipSelectEditMenu: STM32G070KB ST STM32G070KB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32G070xx
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32G0xx_HAL_Driver/Inc; ../Drivers/STM32G0xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32G0xx/Include; ../Drivers/CMSIS/Include; E:\STM32\STM32MXCUBE\STM32G070\Z_F_ZHUANG\APP\Inc; E:\STM32\STM32MXCUBE\STM32G070\Z_F_ZHUANG\RT-Thread\components\finsh; E:\STM32\STM32MXCUBE\STM32G070\Z_F_ZHUANG\RT-Thread\include\libc; E:\STM32\STM32MXCUBE\STM32G070\Z_F_ZHUANG\RT-Thread\include; E:\STM32\STM32MXCUBE\STM32G070\Z_F_ZHUANG\RT-Thread\libcpu
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: RTT-nano.bin
  ILINK.IlinkOutputFile: RTT-nano.out
  ILINK.IlinkIcfFile: stm32g070xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group APP
    ../APP/: adc.c common.c dma.c eeprom.c inflash.c iwdg.c led.c modbus_asc.c modbus_ascii.c tim.c usart.c
  group Application/EWARM
    ./: startup_stm32g070xx.s
  group Application/User
    ../Src/: board.c main.c stm32g0xx_hal_msp.c stm32g0xx_it.c system_clock.c
    ../APP/: para.c system.c task.c
    ../Inc/: rtconfig.h
  group Drivers/CMSIS
    ../Src/: system_stm32g0xx.c
  group Drivers/STM32G0xx_HAL_Driver
    ../Drivers/STM32G0xx_HAL_Driver/Src/: stm32g0xx_hal.c stm32g0xx_hal_adc.c stm32g0xx_hal_adc_ex.c stm32g0xx_hal_cortex.c stm32g0xx_hal_dma.c stm32g0xx_hal_dma_ex.c stm32g0xx_hal_exti.c stm32g0xx_hal_flash.c stm32g0xx_hal_flash_ex.c stm32g0xx_hal_gpio.c stm32g0xx_hal_iwdg.c stm32g0xx_hal_pwr.c stm32g0xx_hal_pwr_ex.c stm32g0xx_hal_rcc.c stm32g0xx_hal_rcc_ex.c stm32g0xx_hal_tim.c stm32g0xx_hal_tim_ex.c stm32g0xx_hal_uart.c stm32g0xx_hal_uart_ex.c stm32g0xx_ll_adc.c stm32g0xx_ll_rcc.c
  group RT-Thread/Finish
    ../RT-Thread/components/finsh/: cmd.c msh.c shell.c
  group RT-Thread/Kernel
    ../RT-Thread/src/: clock.c components.c cpu.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c slab.c thread.c timer.c
  group RT-Thread/Ports
    ../RT-Thread/libcpu/arm/cortex-m0/: context_iar.S cpuport.c
